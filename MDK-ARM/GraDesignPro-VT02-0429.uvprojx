# Keil uVision project GraDesignPro-VT02-0429.uvprojx, settings and files
target GraDesignPro-VT02-0429 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: GraDesignPro-VT02-0429 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F4xx_HAL_../Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;    ../Drivers/CMSIS/Include;    ..\hardware\led;    ..\hardware\key;    ..\hardware\exti_test;    ..\hardware\lcd_drive;    ..\hardware\touch;    ..\hardware\GUI;    ..\hardware\w25q64;    ..\hardware\tftDisp;    ..\hardware\dht22;    ..\hardware\dht12;    ..\hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/Bsp
    ../hardware/dht12/: dht12.c
    ../hardware/GUI/: GUI.c
    ../hardware/lcd_drive/: lcd_drive.c
    ../hardware/led/: led.c
    ../hardware/tftDisp/: tftDisp.c
    ../hardware/touch/: touch.c
    ../hardware/w25q64/: w25q64.c
    ../hardware/: esp8266.c nrf24l0.c
    ../Src/: common.c debug.c flash.c ov7670.c pic_buffer.c sccb.c sensor.c window.c config.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_crc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal.c stm32f4xx_hal_rtc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_flash.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: gpio.c adc.c dma.c stm32f4xx_hal_msp.c usart.c stm32f4xx_it.c tim.c crc.c rtc.c spi.c iwdg.c fsmc.c main.c
software components: CMSIS:CORE 4.1.0
